<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>zigbee2_q1_phy</value></param>
<param><key>title</key><value>zigbee2_q1_phy</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>zigbee</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_table</value></param>
<param><key>value</key><value>numpy.conjugate([0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,1,0.707107+0.707107j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1, 0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,1,0.707107+0.707107j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1, 0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1, 0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1, 0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j, 0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j, 0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,1,0.707107+0.707107j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1, 0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,1,0.707107+0.707107j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1, 0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j, 0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j, 0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j, 0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j, 0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1, 0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1, 0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j, 0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2000000*samples_per_chip</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chip_table_original</value></param>
<param><key>value</key><value>[1+1j,-1+1j,1-1j,-1+1j,1+1j,-1-1j,-1-1j,1+1j,-1+1j,-1+1j,-1-1j,1-1j,-1-1j,1-1j,1+1j,1-1j,1+1j,1-1j,1+1j,-1+1j,1-1j,-1+1j,1+1j,-1-1j,-1-1j,1+1j,-1+1j,-1+1j,-1-1j,1-1j,-1-1j,1-1j,-1-1j,1-1j,1+1j,1-1j,1+1j,-1+1j,1-1j,-1+1j,1+1j,-1-1j,-1-1j,1+1j,-1+1j,-1+1j,-1-1j,1-1j,-1-1j,1-1j,-1-1j,1-1j,1+1j,1-1j,1+1j,-1+1j,1-1j,-1+1j,1+1j,-1-1j,-1-1j,1+1j,-1+1j,-1+1j,-1+1j,-1+1j,-1-1j,1-1j,-1-1j,1-1j,1+1j,1-1j,1+1j,-1+1j,1-1j,-1+1j,1+1j,-1-1j,-1-1j,1+1j,-1-1j,1+1j,-1+1j,-1+1j,-1-1j,1-1j,-1-1j,1-1j,1+1j,1-1j,1+1j,-1+1j,1-1j,-1+1j,1+1j,-1-1j,1+1j,-1-1j,-1-1j,1+1j,-1+1j,-1+1j,-1-1j,1-1j,-1-1j,1-1j,1+1j,1-1j,1+1j,-1+1j,1-1j,-1+1j,1-1j,-1+1j,1+1j,-1-1j,-1-1j,1+1j,-1+1j,-1+1j,-1-1j,1-1j,-1-1j,1-1j,1+1j,1-1j,1+1j,-1+1j,1-1j,-1-1j,1+1j,-1-1j,1-1j,-1+1j,-1+1j,1-1j,-1-1j,-1-1j,-1+1j,1+1j,-1+1j,1+1j,1-1j,1+1j,1-1j,1+1j,1-1j,-1-1j,1+1j,-1-1j,1-1j,-1+1j,-1+1j,1-1j,-1-1j,-1-1j,-1+1j,1+1j,-1+1j,1+1j,-1+1j,1+1j,1-1j,1+1j,1-1j,-1-1j,1+1j,-1-1j,1-1j,-1+1j,-1+1j,1-1j,-1-1j,-1-1j,-1+1j,1+1j,-1+1j,1+1j,-1+1j,1+1j,1-1j,1+1j,1-1j,-1-1j,1+1j,-1-1j,1-1j,-1+1j,-1+1j,1-1j,-1-1j,-1-1j,-1-1j,-1-1j,-1+1j,1+1j,-1+1j,1+1j,1-1j,1+1j,1-1j,-1-1j,1+1j,-1-1j,1-1j,-1+1j,-1+1j,1-1j,-1+1j,1-1j,-1-1j,-1-1j,-1+1j,1+1j,-1+1j,1+1j,1-1j,1+1j,1-1j,-1-1j,1+1j,-1-1j,1-1j,-1+1j,1-1j,-1+1j,-1+1j,1-1j,-1-1j,-1-1j,-1+1j,1+1j,-1+1j,1+1j,1-1j,1+1j,1-1j,-1-1j,1+1j,-1-1j,1+1j,-1-1j,1-1j,-1+1j,-1+1j,1-1j,-1-1j,-1-1j,-1+1j,1+1j,-1+1j,1+1j,1-1j,1+1j,1-1j,-1-1j]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chip_table_remapped</value></param>
<param><key>value</key><value>[(1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>look_window</value></param>
<param><key>value</key><value>32*2*5*samples_per_chip</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pulse_table_original</value></param>
<param><key>value</key><value>(-1,-1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,1,1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,1,1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,1,1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,1,1,1,1,1,1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,1,1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,1,1,1,1,1,1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,1,1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,1,1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,1,1,-1,-1,1,1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,1,1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pulse_table</value></param>
<param><key>value</key><value>pulse_table_original</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>training</value></param>
<param><key>value</key><value>[0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>training_q1</value></param>
<param><key>value</key><value>1.4204e-14+1j,1-8.8137e-15j,-3.4234e-15-1j,-1-1.9669e-15j,7.3572e-15-1j,-1+4.4096e-14j,-3.8706e-14-1j,-1+3.3315e-14j,2.7925e-14+1j,1-2.2535e-14j,-1.7144e-14-1j,1-1.1754e-14j,-6.3638e-15-1j,-1+9.7353e-16j,-4.4168e-15+1j,-1+4.7036e-14j,-4.1646e-14-1j,1-3.6256e-14j,3.0865e-14+1j,-1+2.5475e-14j,-2.0085e-14-1j,-1+1.4695e-14j,9.3042e-15+1j,1-3.9139e-15j,-1.4764e-15+1j,-1-6.8667e-15j,4.4586e-14+1j,1-3.9196e-14j,3.3806e-14+1j,1-2.8416e-14j,-2.3025e-14-1j,1-1.7635e-14j,-1.2245e-14-1j,1-6.8543e-15j,1.464e-15+1j,-1-3.9263e-15j,-9.3166e-15+1j,1-4.2137e-14j,3.6746e-14+1j,-1+3.1356e-14j,2.5966e-14+1j,-1+2.0575e-14j,-1.5185e-14-1j,-1+9.7947e-15j,4.4044e-15+1j,-1-9.8591e-16j,6.3762e-15-1j,1+1.1767e-14j,-3.9687e-14-1j,1-3.4296e-14j,-2.8906e-14-1j,1-2.3516e-14j,1.8125e-14+1j,-1+1.2735e-14j,-7.3448e-15-1j,-1+1.9545e-15j,3.4358e-15-1j,1+8.8261e-15j,4.2627e-14+1j,1-3.7237e-14j,-3.1846e-14-1j,-1+2.6456e-14j,2.1066e-14+1j,-1+1.5675e-14j,1.0285e-14+1j,1-4.8949e-15j,-4.9543e-16+1j,-1-5.8857e-15j,-1.1276e-14+1j,-1+4.0177e-14j,-3.4787e-14-1j,-1+2.9396e-14j,2.4006e-14+1j,-1+1.8616e-14j,-1.3226e-14-1j,1-7.8353e-15j,-2.445e-15-1j,1+2.9453e-15j,8.3356e-15-1j,1-4.3117e-14j,3.7727e-14+1j,-1+3.2337e-14j,-2.6947e-14-1j,-1+2.1556e-14j,-1.6166e-14-1j,1-1.0776e-14j,5.3854e-15+1j,1+4.9518e-18j,5.3953e-15-1j,-1-1.0786e-14j,4.0668e-14+1j,1-3.5277e-14j,-2.9887e-14-1j,1-2.4497e-14j,1.9106e-14+1j,-1+1.3716e-14j,8.3257e-15+1j,1-2.9354e-15j,-2.4549e-15+1j,-1-7.8452e-15j,-1.3235e-14+1j,-1+3.8218e-14j,-3.2827e-14-1j,-1+2.7437e-14j,2.2047e-14+1j,-1+1.6656e-14j,-1.1266e-14-1j,1-5.8758e-15j,-4.8553e-16-1j,1+4.9048e-15j,1.0295e-14-1j,1+1.5685e-14j,3.5768e-14+1j,-1+3.0377e-14j,-2.4987e-14-1j,-1+1.9597e-14j,-1.4207e-14-1j,1-8.8162e-15j,3.4259e-15+1j,1+1.9644e-15j,7.3547e-15-1j,-1-1.2745e-14j,3.8708e-14+1j,1-3.3318e-14j,-2.7928e-14-1j,1-2.2537e-14j,1.7147e-14+1j,-1+1.1757e-14j,6.3663e-15+1j,1-9.76e-16j,-4.4143e-15+1j,-1-9.8046e-15j,-1.5195e-14+1j,-1+3.6258e-14j,-3.0868e-14-1j,-1+2.5478e-14j,2.0087e-14+1j,-1+1.4697e-14j,-9.3067e-15-1j,1-3.9164e-15j,1.4739e-15-1j,1+6.8642e-15j,1.2255e-14-1j,1-3.9199e-14j,3.3808e-14+1j,-1+2.8418e-14j,-2.3028e-14-1j,-1+1.7637e-14j,-1.2247e-14-1j,1-6.8568e-15j,1.4665e-15+1j,1+3.9238e-15j,9.3141e-15-1j,-1-1.4704e-14j,3.6749e-14+1j,1-3.1358e-14j,-2.5968e-14-1j,1-2.0578e-14j,1.5187e-14+1j,-1+9.7972e-15j,4.4069e-15+1j,1+9.8343e-16j,2.2048e-14+1j,-1+1.6658e-14j,1.1267e-14+1j,-1+5.8771e-15j,-4.8676e-16-1j,-1+2.3518e-14j,1.8128e-14+1j,-1+1.2738e-14j,-7.3473e-15-1j,1-1.957e-15j,3.4333e-15-1j,1-1.9598e-14j,-1.4208e-14-1j,1-8.8175e-15j,3.4272e-15+1j,-1-1.9631e-15j,-2.1068e-14-1j,-1+1.5678e-14j,-1.0288e-14-1j,1-4.8973e-15j,-4.9295e-16+1j,1+5.8833e-15j,-1.7148e-14-1j,-1+1.1758e-14j,6.3675e-15+1j,1-9.7724e-16j,4.4131e-15-1j,1-1.8618e-14j,1.3228e-14+1j,-1+7.8377e-15j,2.4474e-15+1j,1+2.9429e-15j,2.0089e-14+1j,-1+1.4698e-14j,9.3079e-15+1j,-1+3.9176e-15j,1.4727e-15-1j,-1+2.1559e-14j,1.6168e-14+1j,-1+1.0778e-14j,-5.3878e-15-1j,1+2.4759e-18j,5.3928e-15-1j,1-1.7639e-14j,-1.2248e-14-1j,1-6.858e-15j,1.4677e-15+1j,-1-3.9226e-15j,-1.9109e-14-1j,-1+1.3719e-14j,-8.3282e-15-1j,1-2.9379e-15j,-2.4524e-15+1j,1+7.8427e-15j,-1.5189e-14-1j,-1+9.7984e-15j,4.4081e-15+1j,1+9.8219e-16j,6.3725e-15-1j,1-1.6659e-14j,1.1269e-14+1j,-1+5.8783e-15j,4.88e-16+1j,1+4.9023e-15j,1.8129e-14+1j,-1+1.2739e-14j,7.3485e-15+1j,-1+1.9582e-15j,3.4321e-15-1j,-1+1.9599e-14j,1.4209e-14+1j,-1+8.8187e-15j,-3.4284e-15-1j,1+1.9619e-15j,7.3522e-15-1j,1-1.5679e-14j,-1.0289e-14-1j,1-4.8986e-15j,-4.9172e-16+1j,-1+8.3288e-15j,-2.9385e-15-1j,-1+1.1759e-14j,-6.3688e-15-1j,1-9.7848e-16j,9.799e-15+1j,1-4.4087e-15j,9.8157e-16-1j,-1+7.839e-15j,2.4487e-15+1j,1+2.9416e-15j,-5.8789e-15-1j,1-4.8862e-16j,9.3092e-15+1j,-1+3.9189e-15j,-1.4714e-15+1j,1-7.3491e-15j,1.9588e-15+1j,-1+1.0779e-14j,5.3891e-15+1j,-1-1.238e-18j,-8.8193e-15-1j,-1+3.429e-15j,-1.9613e-15+1j,-1+6.8593e-15j,-1.469e-15-1j,1+3.9213e-15j,-4.8992e-15-1j,1+4.911e-16j,-8.3295e-15-1j,1-2.9392e-15j,-2.4512e-15+1j,-1+6.3694e-15j,-9.791e-16-1j,-1+9.7997e-15j,-4.4093e-15-1j,1+9.8096e-16j,7.8396e-15+1j,1-2.4493e-15j,-4.1644e-15-1j,-1+5.8795e-15j,4.8924e-16+1j,1-2.2044e-15j,-3.9195e-15-1j,1+1.4708e-15j,2.4431e-16+1j,-1+1.9594e-15j,3.6746e-15+1j,1-5.3897e-15j,-6.1898e-19+1j,-1+1.7145e-15j,3.4296e-15+1j,-1-1.9607e-15j,2.4555e-16-1j,-1+1.4696e-15j,3.1847e-15+1j,-1+4.8998e-15j,4.9048e-16-1j,1-1.2246e-15j,-2.9398e-15-1j,1-1.1022e-15j,7.3541e-16-1j,1-9.7972e-16j,2.6948e-15+1j,-1+8.5725e-16j,9.8034e-16-1j,-1+7.3479e-16j,-2.4499e-15-1j,1-6.1232e-16j,5.5109e-16+1j,1-4.8986e-16j,-4.2863e-16-1j,-1+3.6739e-16j,3.0616e-16+1j,1-2.4493e-16j,-1.837e-16-1j,1-1.2246e-16j,6.1232e-17+1j,1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samples_per_chip</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_table_q1</value></param>
<param><key>value</key><value>numpy.conjugate([0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,-0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,-0.70711+0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,-0.70711-0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,-0.70711+0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,-0.70711+0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,-0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711+0.70711j,0.70711+0.70711j,0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711-0.70711j,0.70711-0.70711j,0.70711-0.70711j,-0.70711-0.70711j,-0.70711+0.70711j,-0.70711+0.70711j])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>peak_o_var</value></param>
<param><key>value</key><value>32*10*samples_per_chip</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>txin</value></param>
<param><key>type</key><value>message</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>lower nipple is sent first</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>pdu_length</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>maps chunks of 4 bis directly to qpsk symbols</value></param>
</block>
<block>
<key>blocks_packed_to_unpacked_xx</key>
<param><key>id</key><value>blocks_packed_to_unpacked_xx_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>bits_per_chunk</key><value>4</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>look_window</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>32*2*21*samples_per_chip</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>alpha</value></param>
<param><key>value</key><value>0.001</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import sin, pi</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>delay</key><value>samples_per_chip</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>txout</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>ieee802_15_4_access_code_prefixer</key>
<param><key>id</key><value>ieee802_15_4_access_code_prefixer_0</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>chip_table_original</value></param>
<param><key>dimension</key><value>16</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>interp</key><value>2*samples_per_chip</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>acq_threshold_dB</value></param>
<param><key>label</key><value>acq_threshold_dB</value></param>
<param><key>value</key><value>-12.5</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>[0, sin(pi/4), 1, sin(3*pi/4)]</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>label</key><value>rxout</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>rxin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_peak_detector2_fb</key>
<param><key>id</key><value>blocks_peak_detector2_fb_0</value></param>
<param><key>threshold_factor_rise</key><value>10**(acq_threshold_dB/10)*peak_o_var</value></param>
<param><key>look_ahead</key><value>look_window</value></param>
<param><key>alpha</key><value>alpha</value></param>
<param><key>cont_avg</key><value>True</value></param>
<param><key>fixed_window</key><value>True</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_3_0_0_1_0_2</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/flags</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_3_0_0_1_0</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/output</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>tap_delayed_filter_hier</key>
<param><key>id</key><value>tap_delayed_filter_hier_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>pulse_table</key><value>pulse_table</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>gain</key><value>1</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>alpha</key><value>0.00016</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>training</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_3_0_0_1_0_0</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/avg</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>foo_burst_tagger</key>
<param><key>id</key><value>foo_burst_tagger_0</value></param>
<param><key>tag_name</key><value>pmt.intern("pdu_length")</value></param>
<param><key>mult</key><value>64*samples_per_chip</value></param>
</block>
<block>
<key>tap_delayed_filter_ccc_hier</key>
<param><key>id</key><value>tap_delayed_filter_ccc_hier_0</value></param>
<param><key>training</key><value>training_q1</value></param>
</block>
<block>
<key>zigbee_noncoherent_detector</key>
<param><key>id</key><value>zigbee_noncoherent_detector_0</value></param>
<param><key>symbol_table</key><value>symbol_table_q1</value></param>
<param><key>spc</key><value>samples_per_chip</value></param>
<param><key>preset_N</key><value>-1</value></param>
</block>
<connection><source_block_id>blocks_peak_detector2_fb_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_peak_detector2_fb_0</source_block_id><sink_block_id>blocks_file_sink_0_1_3_0_0_1_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_peak_detector2_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_file_sink_0_1_3_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0_0</source_block_id><sink_block_id>blocks_packed_to_unpacked_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_repeat_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>blocks_repeat_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_packed_to_unpacked_xx_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_access_code_prefixer_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>ieee802_15_4_access_code_prefixer_0</sink_block_id><source_key>0</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_peak_detector2_fb_0</source_block_id><sink_block_id>blocks_file_sink_0_1_3_0_0_1_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>foo_burst_tagger_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_burst_tagger_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_2</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_delay_2</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>tap_delayed_filter_ccc_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>zigbee_noncoherent_detector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_peak_detector2_fb_0</source_block_id><sink_block_id>zigbee_noncoherent_detector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>zigbee_noncoherent_detector_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>msg_out</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1</source_block_id><sink_block_id>blocks_peak_detector2_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>tap_delayed_filter_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tap_delayed_filter_hier_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tap_delayed_filter_hier_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>tap_delayed_filter_ccc_hier_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
