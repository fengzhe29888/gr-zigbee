<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>zigbee2_phy</value></param>
<param><key>title</key><value>zigbee2_phy</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>zigbee</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>look_window</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>32*2*5*samples_per_chip</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pulse_table</value></param>
<param><key>value</key><value>pulse_table_original</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pulse_table_original</value></param>
<param><key>value</key><value>(-1,-1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,1,1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,1,1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,1,1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,1,1,1,1,1,1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,1,1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,1,1,1,1,1,1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,1,1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,1,1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,1,1,-1,-1,1,1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,1,1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,-1,-1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_table</value></param>
<param><key>value</key><value>numpy.conjugate([0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,1,0.707107+0.707107j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1, 0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,1,0.707107+0.707107j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1, 0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1, 0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1, 0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j, 0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j, 0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,1,0.707107+0.707107j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1, 0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,1,0.707107+0.707107j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1, 0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j, 0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j, 0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j, 0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j, 0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1, 0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1, 0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j, 0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0+1j,-0.707107+0.707107j,-1,-0.707107-0.707107j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j,-0.707107+0.707107j,0+1j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,1,0.707107+0.707107j,0.707107+0.707107j,1,0.707107-0.707107j,0-1j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-1,-0.707107-0.707107j,0-1j,0.707107-0.707107j,0.707107-0.707107j,0-1j,-0.707107-0.707107j,-1,-0.707107+0.707107j,0+1j,0+1j,-0.707107+0.707107j])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_table_mapped</value></param>
<param><key>value</key><value>numpy.conjugate([0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0.70711+0.70711j,1,1,0.70711+0.70711j,0.70711+0.70711j,1,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,-0.70711-0.70711j,-1,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,1,0.70711+0.70711j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-1,-0.70711-0.70711j,-0.70711-0.70711j,-1,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0.70711+0.70711j,1,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-1,-0.70711-0.70711j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0.70711+0.70711j,1,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,-0.70711-0.70711j,-1,-1,-0.70711-0.70711j,-0.70711-0.70711j,-1,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-1,-0.70711-0.70711j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0.70711+0.70711j,1,1,0.70711+0.70711j,0.70711+0.70711j,1,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,-0.70711-0.70711j,-1,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,1,0.70711+0.70711j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0.70711+0.70711j,1,1,0.70711+0.70711j,0.70711+0.70711j,1,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,-0.70711-0.70711j,-1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,1,0.70711+0.70711j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,-0.70711-0.70711j,-1,-1,-0.70711-0.70711j,-0.70711-0.70711j,-1,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0.70711+0.70711j,1,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0.70711+0.70711j,1,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,-0.70711-0.70711j,-1,-1,-0.70711-0.70711j,-0.70711-0.70711j,-1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-1,-0.70711-0.70711j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0.70711+0.70711j,1,1,0.70711+0.70711j,0.70711+0.70711j,1,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,-0.70711-0.70711j,-1,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,1,0.70711+0.70711j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0-1j,0.70711-0.70711j,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0+1j,-0.70711+0.70711j])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samples_per_chip</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chip_table_remapped</value></param>
<param><key>value</key><value>[(1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chip_table_original</value></param>
<param><key>value</key><value>[1+1j,-1+1j,1-1j,-1+1j,1+1j,-1-1j,-1-1j,1+1j,-1+1j,-1+1j,-1-1j,1-1j,-1-1j,1-1j,1+1j,1-1j,1+1j,1-1j,1+1j,-1+1j,1-1j,-1+1j,1+1j,-1-1j,-1-1j,1+1j,-1+1j,-1+1j,-1-1j,1-1j,-1-1j,1-1j,-1-1j,1-1j,1+1j,1-1j,1+1j,-1+1j,1-1j,-1+1j,1+1j,-1-1j,-1-1j,1+1j,-1+1j,-1+1j,-1-1j,1-1j,-1-1j,1-1j,-1-1j,1-1j,1+1j,1-1j,1+1j,-1+1j,1-1j,-1+1j,1+1j,-1-1j,-1-1j,1+1j,-1+1j,-1+1j,-1+1j,-1+1j,-1-1j,1-1j,-1-1j,1-1j,1+1j,1-1j,1+1j,-1+1j,1-1j,-1+1j,1+1j,-1-1j,-1-1j,1+1j,-1-1j,1+1j,-1+1j,-1+1j,-1-1j,1-1j,-1-1j,1-1j,1+1j,1-1j,1+1j,-1+1j,1-1j,-1+1j,1+1j,-1-1j,1+1j,-1-1j,-1-1j,1+1j,-1+1j,-1+1j,-1-1j,1-1j,-1-1j,1-1j,1+1j,1-1j,1+1j,-1+1j,1-1j,-1+1j,1-1j,-1+1j,1+1j,-1-1j,-1-1j,1+1j,-1+1j,-1+1j,-1-1j,1-1j,-1-1j,1-1j,1+1j,1-1j,1+1j,-1+1j,1-1j,-1-1j,1+1j,-1-1j,1-1j,-1+1j,-1+1j,1-1j,-1-1j,-1-1j,-1+1j,1+1j,-1+1j,1+1j,1-1j,1+1j,1-1j,1+1j,1-1j,-1-1j,1+1j,-1-1j,1-1j,-1+1j,-1+1j,1-1j,-1-1j,-1-1j,-1+1j,1+1j,-1+1j,1+1j,-1+1j,1+1j,1-1j,1+1j,1-1j,-1-1j,1+1j,-1-1j,1-1j,-1+1j,-1+1j,1-1j,-1-1j,-1-1j,-1+1j,1+1j,-1+1j,1+1j,-1+1j,1+1j,1-1j,1+1j,1-1j,-1-1j,1+1j,-1-1j,1-1j,-1+1j,-1+1j,1-1j,-1-1j,-1-1j,-1-1j,-1-1j,-1+1j,1+1j,-1+1j,1+1j,1-1j,1+1j,1-1j,-1-1j,1+1j,-1-1j,1-1j,-1+1j,-1+1j,1-1j,-1+1j,1-1j,-1-1j,-1-1j,-1+1j,1+1j,-1+1j,1+1j,1-1j,1+1j,1-1j,-1-1j,1+1j,-1-1j,1-1j,-1+1j,1-1j,-1+1j,-1+1j,1-1j,-1-1j,-1-1j,-1+1j,1+1j,-1+1j,1+1j,1-1j,1+1j,1-1j,-1-1j,1+1j,-1-1j,1+1j,-1-1j,1-1j,-1+1j,-1+1j,1-1j,-1-1j,-1-1j,-1+1j,1+1j,-1+1j,1+1j,1-1j,1+1j,1-1j,-1-1j]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>peak_o_var</value></param>
<param><key>value</key><value>32*10*samples_per_chip</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2000000*samples_per_chip</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>training_mapped</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>training_mapped</value></param>
<param><key>value</key><value>-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>training</value></param>
<param><key>value</key><value>[0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,-0.70711+0.70711j,-1,-0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,-0.70711-0.70711j,-1,-0.70711+0.70711j,0+1j,0.70711+0.70711j,1,0.70711-0.70711j,0-1j,0.70711-0.70711j,1,0.70711+0.70711j,0+1j,0.70711+0.70711j,1]</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>txin</value></param>
<param><key>type</key><value>message</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>lower nipple is sent first</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>pdu_length</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>maps chunks of 4 bis directly to qpsk symbols</value></param>
</block>
<block>
<key>blocks_packed_to_unpacked_xx</key>
<param><key>id</key><value>blocks_packed_to_unpacked_xx_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>bits_per_chunk</key><value>4</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>look_window</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>32*2*21*samples_per_chip</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>alpha</value></param>
<param><key>value</key><value>0.001</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import sin, pi</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>delay</key><value>samples_per_chip</value></param>
</block>
<block>
<key>foo_burst_tagger</key>
<param><key>id</key><value>foo_burst_tagger_0</value></param>
<param><key>tag_name</key><value>pmt.intern("pdu_length")</value></param>
<param><key>mult</key><value>128</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>txout</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>ieee802_15_4_access_code_prefixer</key>
<param><key>id</key><value>ieee802_15_4_access_code_prefixer_0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>interp</key><value>2*samples_per_chip</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>[0, sin(pi/4), 1, sin(3*pi/4)]</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>zigbee_noncoherent_detector</key>
<param><key>id</key><value>zigbee_noncoherent_detector_0</value></param>
<param><key>symbol_table</key><value>symbol_table</value></param>
<param><key>spc</key><value>samples_per_chip</value></param>
<param><key>preset_N</key><value>-1</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>rxin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>training</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>chip_table_remapped</value></param>
<param><key>dimension</key><value>16</value></param>
</block>
<block>
<key>tap_delayed_filter_ccc_hier</key>
<param><key>id</key><value>tap_delayed_filter_ccc_hier_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>training</key><value>training</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>alpha</key><value>0.00016</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>tap_delayed_filter_hier</key>
<param><key>id</key><value>tap_delayed_filter_hier_0</value></param>
<param><key>pulse_table</key><value>pulse_table</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>label</key><value>rxout</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>blocks_peak_detector2_fb</key>
<param><key>id</key><value>blocks_peak_detector2_fb_0</value></param>
<param><key>threshold_factor_rise</key><value>10**(acq_threshold_dB/10)*peak_o_var</value></param>
<param><key>look_ahead</key><value>look_window</value></param>
<param><key>alpha</key><value>alpha</value></param>
<param><key>cont_avg</key><value>True</value></param>
<param><key>fixed_window</key><value>True</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_3_0_0_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/output</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_3_0_0_1_0_2</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/flags</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_3_0_0_1_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/avg</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>acq_threshold_dB</value></param>
<param><key>label</key><value>acq_threshold_dB</value></param>
<param><key>value</key><value>-14.6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>look_window</value></param>
<param><key>label</key><value>look_window</value></param>
<param><key>value</key><value>64*2*5</value></param>
</block>
<connection><source_block_id>blocks_peak_detector2_fb_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_peak_detector2_fb_0</source_block_id><sink_block_id>blocks_file_sink_0_1_3_0_0_1_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_peak_detector2_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_file_sink_0_1_3_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0_0</source_block_id><sink_block_id>blocks_packed_to_unpacked_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_repeat_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>blocks_repeat_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_packed_to_unpacked_xx_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_access_code_prefixer_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>ieee802_15_4_access_code_prefixer_0</sink_block_id><source_key>0</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_peak_detector2_fb_0</source_block_id><sink_block_id>blocks_file_sink_0_1_3_0_0_1_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>foo_burst_tagger_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_burst_tagger_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_2</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_delay_2</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>tap_delayed_filter_ccc_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>zigbee_noncoherent_detector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_peak_detector2_fb_0</source_block_id><sink_block_id>zigbee_noncoherent_detector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>zigbee_noncoherent_detector_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>msg_out</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tap_delayed_filter_ccc_hier_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>tap_delayed_filter_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tap_delayed_filter_hier_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>tap_delayed_filter_hier_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1</source_block_id><sink_block_id>blocks_peak_detector2_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1</source_block_id><sink_block_id>blocks_file_sink_0_1_3_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
